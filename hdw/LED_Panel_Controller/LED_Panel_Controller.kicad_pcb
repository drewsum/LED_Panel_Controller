# Repository drewsum/LED_Panel_Controller (continued)

## KiCad design hdw/LED_Panel_Controller/LED_Panel_Controller.kicad_pcb (continued)

Schematic: I2C_Boost.sch, LED Panel Controller

Parts:
C1301, C1302: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
U1301: LTC1694; SOT-23-5; Digi-Key PN LTC1694CS5#TRPBFCT-ND
U1302: AT24CS32-STUM; SOT-23-5; Digi-Key PN AT24CS32-STUM-T

Connections:
I2C_SCL: U1301.5 (SMBUS1), U1302.1 (SCL); also elsewhere on the board
I2C_SDA: U1301.4 (SMBUS2), U1302.3 (SDA); also elsewhere on the board

Schematic: Platform_ETC.sch, LED Panel Controller

Parts:
C1401, C1402, C1403: 10uF; C_0402; Voltage 6.3V; Digi-Key PN 1276-1451-1-ND
C1404: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
D1401: BAT48JFILM; D_SOD-323; Digi-Key PN 497-5711-1-ND
DOC1401: 0x6B
U1401: DS1683; SOIC-8_3.9x4.9mm_Pitch1.27mm; Digi-Key PN DS1683S+-ND

Connections:
I2C_SCL: U1401.5 (SCL); also elsewhere on the board
I2C_SDA: U1401.6 (SDA); also elsewhere on the board
unnamed: C1401.1, C1402.1, C1403.1, C1404.1, D1401.1 (K), U1401.8 (VCC)

Schematic: USB_UART_Bridge.sch, LED Panel Controller

Parts:
C1203: 10uF; C_0402; Voltage 6.3V; Digi-Key PN 1276-1451-1-ND
C1204, C1501, C1502, C1505, C1506, C1507, C1508: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
C1509, C1510: 47pF; C_0402; Voltage 50V; Digi-Key PN 311-3783-1-ND
D1501: Yellow; LED_0402; Digi-Key PN 1497-1198-1-ND
DOC1501: COM_Port_Settings
J1501: USB_B_Mini; USB_Mini-B; Digi-Key PN 732-2109-1-ND
L1501, L1502: 600R 0.5A; L_0402; Digi-Key PN 490-5441-1-ND
R1206, R1207, R1216, R1217: 100k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT100KCT-ND
R1208, R1215: 10; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10R0CT-ND
R1209: 0.02; R_0612; Tolerance 1%; Digi-Key PN P16010CT-ND
R1210, R1211, R1212: 0; R_0402; Tolerance 1%; Digi-Key PN RMCF0402ZT0R00CT-N
R1501: 1k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT1K00CT-ND
R1502: 487k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT487KCT-ND
R1503: 6.04k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT6K04CT-ND
R1504: 40.2k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT40K2CT-ND
R1507: 10k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10K0CT-ND
R1515, R1516: 27; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT27R0CT-ND
TP1201: TP; Test_Point
U1501: TLV6700; SOT-23-6; Digi-Key PN 296-51696-1-ND
U1502: FT234XD; DFN-12-1EP_3x3mm_Pitch0.45mm; Digi-Key PN 768-1178-1-ND
U1503: TXB0102DCU; VSSOP-8_2.4x2.1mm_P0.5mm; Digi-Key PN 296-22862-1-ND
U1504: TPD3S014DBVR; SOT-23-6; Digi-Key PN 296-38835-1-ND

Connections:
+3.3V_USB: C1501.1, C1507.1, C1508.1, U1502.3 (3V3OUT), U1502.9 (VCCIO), U1503.7 (VCCB); also elsewhere on the board
/USB UART Bridge/BRIDGE_USB+: R1515.2, U1502.12 (USBDP)
/USB UART Bridge/BRIDGE_USB-: R1516.2, U1502.1 (USBDM)
/USB UART Bridge/CONN_USB+: C1509.1, J1501.3 (D+), R1515.1, U1504.6 (D1)
/USB UART Bridge/CONN_USB-: C1510.1, J1501.2 (D-), R1516.1, U1504.5 (D2)
unnamed: D1501.2 (A), R1501.2
unnamed: J1501.1 (VBUS), L1501.1
unnamed: J1501.6 (Shield), L1502.2
unnamed: L1501.2, U1504.1 (EN), U1504.3 (IN)
unnamed: R1502.2, R1503.1, U1501.3 (+INA)
unnamed: R1503.2, R1504.1, U1501.4 (-INB)
PIC32MZ_UART_RX_BUF: U1502.7 (TXD), U1503.8 (B1); also elsewhere on the board
PIC32MZ_UART_TX_BUF: U1502.10 (RXD), U1503.1 (B2); also elsewhere on the board
POS5_USB_PGOOD: R1507.2, U1501.1 (OUTA), U1501.6 (OUTB), U1503.6 (OE); also elsewhere on the board
~USB_ACTIVE: D1501.1 (K), U1502.6 (CBUS0)

Notes on the sheet:
Note: All components on this sheet have "Configuration" field set to "USB", unless otherwise noted
Note: All components within box appear on all configurations

Schematic: USB_Telemetry.sch, LED Panel Controller

Parts:
C1601, C1602, C1603: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
DOC1601: 0x43
DOC1602: 0x1D
U1601: INA219BxDCN; SOT-23-8; Digi-Key PN 296-46420-1-ND
U1602: MCP9804; DFN-8-1EP_3x2mm_P0.5mm_EP1.3x1.5mm; Digi-Key PN MCP9804T-E/MCCT-ND

Connections:
I2C_SCL: U1601.5 (SCL), U1601.7 (A0), U1602.2 (SCL); also elsewhere on the board
I2C_SDA: U1601.6 (SDA), U1602.1 (SDA); also elsewhere on the board
POS5_USB_SNS+: C1601.1, U1601.1 (IN+); also elsewhere on the board
POS5_USB_SNS-: C1601.2, U1601.2 (IN-); also elsewhere on the board

Schematic: SD_Card_Slot.sch, LED Panel Controller

Parts:
C1701, C1703, C1705: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
C1702, C1704: 10uF; C_0402; Voltage 6.3V; Digi-Key PN 1276-1451-1-ND
D1701: Green; LED_0402; Digi-Key PN 1497-1219-1-ND
D1702: SP0505BAJT; SOT-363_SC-70-6; Digi-Key PN F3160CT-ND
J1701: Micro_SD_Card_Det_Hirose_DM3AT; Hirose_DM3AT-SF-PEJM5; Digi-Key PN HR1964CT-ND
L1701: 600R 0.5A; L_0402; Digi-Key PN 490-5441-1-ND
R1701: 1k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT1K00CT-ND
R1702, R1709, R1710, R1711: 10; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10R0CT-ND
R1703, R1704, R1705, R1706, R1707, R1708: 10k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10K0CT-ND
U1701, U1702: 74LVC1G97; SOT-363_SC-70-6; Digi-Key PN 1727-1772-1-ND

Connections:
unnamed: D1701.1 (K), U1701.4
unnamed: D1701.2 (A), R1701.2
unnamed: D1702.3 (K), J1701.10 (DET_A), R1711.1
unnamed: D1702.4 (K), J1701.7 (DAT0), R1702.1
unnamed: D1702.5 (K), J1701.5 (CLK), R1710.1
unnamed: D1702.6 (K), J1701.3 (CMD), R1709.1
unnamed: J1701.11 (SHIELD), L1701.2
SD_SPI_MISO: R1702.2, R1707.2; also elsewhere on the board
SD_SPI_MOSI: R1704.2, R1709.2; also elsewhere on the board
SD_SPI_SCK: R1706.2, R1710.2; also elsewhere on the board
~SD_CARD_DET: R1705.2, U1702.4; also elsewhere on the board
~SD_CARD_DET_R: C1702.1, R1708.2, R1711.2, U1702.1
~SD_SPI_CS: D1702.1 (K), J1701.2 (DAT3/CD), R1703.2, U1701.6; also elsewhere on the board

Schematic: MLVDS_Port.sch, LED Panel Controller

Parts:
C1801, C1803, C1804, C1805, C1806: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
C1802, C1807, C1808: 10uF; C_0402; Voltage 6.3V; Digi-Key PN 1276-1451-1-ND
J1801: Multidrop Expansion; IDC-Header_2x10_P2.54mm_Vertical; Digi-Key PN 732-2096-ND
J1802: Force SS; PinHeader_1x02_P2.54mm_Vertical
R1801, R1802, R1803, R1804, R1805, R1806, R1807, R1808, R1818: 10K; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10K0CT-ND
R1809, R1810, R1811, R1812: 120; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT120RCT-ND
R1813, R1814, R1815, R1816, R1817: 0; R_0402; Tolerance 1%; Digi-Key PN RMCF0402ZT0R00CT-N
U1801, U1802: SN65MLVD3; DFN-8-1EP_3x3mm_Pitch0.65mm; Digi-Key PN 296-21314-1-ND
U1803, U1804: 74LVC1G97; SOT-363_SC-70-6; Digi-Key PN 1727-1772-1-ND
U1805: THVD1552; VSSOP-10_3x3mm_P0.5mm; Digi-Key PN 296-51654-1-ND

Connections:
MLVDS_SPI_MOSI: R1801.2, U1801.3 (R); also elsewhere on the board
MLVDS_SPI_MOSI+: J1801.2, R1809.1, U1801.6 (A)
MLVDS_SPI_MOSI-: J1801.3, R1809.2, U1801.7 (B)
MLVDS_SPI_SCK: R1802.2, U1802.3 (R); also elsewhere on the board
MLVDS_SPI_SCK+: J1801.5, R1810.1, U1802.6 (A)
MLVDS_SPI_SCK-: J1801.6, R1810.2, U1802.7 (B)
MODULE_DE: R1808.1, U1804.4, U1805.3 (DE)
RS422_UART_RX: R1803.2, U1805.1 (R); also elsewhere on the board
RS422_UART_RX+: J1801.18, R1811.2, U1805.9 (A)
RS422_UART_RX-: J1801.19, R1811.1, U1805.8 (B)
RS422_UART_TX: R1807.2, U1805.4 (D); also elsewhere on the board
RS422_UART_TX+: J1801.15, R1812.1, U1805.6 (Y)
RS422_UART_TX-: J1801.16, R1812.2, U1805.7 (Z)
~MODULE_RE: R1804.2, R1805.2, R1806.2, U1801.2 (~RE), U1802.2 (~RE), U1803.4, U1805.2 (~RE); also elsewhere on the board
~MODULE_SS: R1813.1, R1814.1, R1815.1, R1816.1, R1817.1, R1818.2, U1803.1, U1804.6
~MODULE_SS0: J1801.8, J1802.1, R1813.2
~MODULE_SS1: J1801.9, R1814.2
~MODULE_SS2: J1801.10, R1815.2
~MODULE_SS3: J1801.11, R1816.2
~MODULE_SS4: J1801.12, R1817.2

Schematic: PGOOD_LEDs.sch, LED Panel Controller

Parts:
C1901, C1902, C1903, C1904, C1905: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
D1901, D1902, D1903, D1905: Green; LED_0402; Digi-Key PN 1497-1219-1-ND
D1904: Red; LED_0402; Digi-Key PN 1497-1174-1-ND
R1901: 10k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10K0CT-ND
R1902, R1903, R1904, R1905, R1906: 1k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT1K00CT-ND
U1901, U1902, U1903, U1904, U1905: 74LVC1G97; SOT-363_SC-70-6; Digi-Key PN 1727-1772-1-ND

Connections:
unnamed: D1901.1 (K), U1901.4
unnamed: D1901.2 (A), R1902.2
unnamed: D1902.1 (K), U1902.4
unnamed: D1902.2 (A), R1903.2
unnamed: D1903.1 (K), U1903.4
unnamed: D1903.2 (A), R1904.2
unnamed: D1904.1 (K), U1904.4
unnamed: D1904.2 (A), R1905.2
unnamed: D1905.1 (K), U1905.4
unnamed: D1905.2 (A), R1906.2
PGOOD_LED_SHDN: R1901.1, U1901.3, U1902.3, U1903.3, U1904.6, U1905.3; also elsewhere on the board
POS3P3_PGOOD: U1905.6; also elsewhere on the board
POS5_PGOOD: U1902.6; also elsewhere on the board
POS5_USB_PGOOD: U1903.6; also elsewhere on the board
POS12_PGOOD: U1901.6; also elsewhere on the board
VBAT_PGOOD: U1904.1; also elsewhere on the board

Schematic: Status_LEDs.sch, LED Panel Controller

Parts:
C2001, C2002, C2003, C2004: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
D2001: Green; LED_0402; Digi-Key PN 1497-1219-1-ND
D2002, D2003, D2004: Red; LED_0402; Digi-Key PN 1497-1174-1-ND
R2001, R2002, R2005, R2006: 10k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10K0CT-ND
R2003, R2004, R2007, R2008: 1k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT1K00CT-ND
U2001, U2002, U2003, U2004: 74LVC1G97; SOT-363_SC-70-6; Digi-Key PN 1727-1772-1-ND

Connections:
CPU_Trap_LED: R2006.1, U2004.6; also elsewhere on the board
Error_LED: R2002.1, U2002.6; also elsewhere on the board
Heartbeat_LED: R2001.1, U2001.6; also elsewhere on the board
unnamed: D2001.1 (K), U2001.4
unnamed: D2001.2 (A), R2003.2
unnamed: D2002.1 (K), U2002.4
unnamed: D2002.2 (A), R2004.2
unnamed: D2003.1 (K), U2003.4
unnamed: D2003.2 (A), R2007.2
unnamed: D2004.1 (K), U2004.4
unnamed: D2004.2 (A), R2008.2
Reset_LED: R2005.2, U2003.6; also elsewhere on the board

Schematic: Backup_RTC.sch, LED Panel Controller

Parts:
BT2101: CR1616; Digi-Key PN P034-ND
BT2102: CR1616_Holder; BAT_BU1632SM-JJ-GTR; Digi-Key PN BU1632SM-JJ-GCT-ND
C2101, C2103, C2104, C2105: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
C2102: 10uF; C_0402; Voltage 6.3V; Digi-Key PN 1276-1451-1-ND
DOC2101: 0x68
R2101: 1.07M; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT1M07CT-ND
R2102: 220k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT220KCT-ND
R2103: 10k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10K0CT-ND
TP2101: TP; Test_Point
U2101: DS3231MZ; SOIC-8_3.9x4.9mm_P1.27mm; Digi-Key PN DS3231MZ+-ND
U2102: TLV6700; SOT-23-6; Digi-Key PN 296-51696-1-ND

Connections:
I2C_SCL: U2101.8 (SCL); also elsewhere on the board
I2C_SDA: U2101.7 (SDA); also elsewhere on the board
VBAT: BT2102.1 (+), C2102.1, C2103.1, R2101.1, TP2101.1, U2101.6 (VBAT)
VBAT_ADC: C2101.1, R2101.2, R2102.1, U2102.3 (+INA); also elsewhere on the board
VBAT_PGOOD: R2103.2, U2102.1 (OUTA); also elsewhere on the board

Notes on the sheet:
Falling threshold set to 2.5V

Schematic: Pushbuttons.sch, LED Panel Controller

Parts:
C2201, C2202: 10nF; C_0402; Voltage 50V; Digi-Key PN 399-3066-1-ND
C2203, C2204, C2207, C2208: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
C2205, C2206: 10uF; C_0402; Voltage 6.3V; Digi-Key PN 1276-1451-1-ND
R2201, R2202, R2203, R2204: 1k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT1K00CT-ND
R2205, R2206, R2207, R2208, R2209, R2210: 10k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10K0CT-ND
SW2201, SW2202: Cap_Touch; Capacitive_Touch_Pad
U2201, U2202: AT42QT1010-TSHR; SOT-23-6; Digi-Key PN AT42QT1010-TSHRCT-ND
U2203, U2204: 74LVC1G97; SOT-363_SC-70-6; Digi-Key PN 1727-1772-1-ND

Connections:
Cap_Touch_Mode: R2210.1, U2204.4; also elsewhere on the board
Cap_Touch_Power: R2209.1, U2203.4; also elsewhere on the board
unnamed: C2201.1, U2201.4 (SNS)
unnamed: C2201.2, R2201.1, R2202.1, U2201.3 (SNSK)
unnamed: C2202.1, U2202.4 (SNS)
unnamed: C2202.2, R2203.1, R2204.1, U2202.3 (SNSK)
unnamed: C2205.1, R2207.1, U2203.1
unnamed: C2206.1, R2208.1, U2204.1
unnamed: R2201.2, R2202.2, SW2201.1
unnamed: R2203.2, R2204.2, SW2202.1
unnamed: R2205.1, R2207.2, U2201.1 (OUT)
unnamed: R2206.1, R2208.2, U2202.1 (OUT)

Schematic: Mode_LEDs.sch, LED Panel Controller

Parts:
C2301, C2302, C2303, C2304, C2305, C2306, C2307, C2308: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
D2301, D2302, D2303, D2304, D2305, D2306, D2307, D2308: Green; LED_0402; Digi-Key PN 1497-1219-1-ND
R2301, R2302, R2303, R2307, R2308, R2309, R2313, R2314: 10k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10K0CT-ND
R2304, R2305, R2306, R2310, R2311, R2312, R2315, R2316: 1k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT1K00CT-ND
U2301, U2302, U2303, U2304, U2305, U2306, U2307, U2308: 74LVC1G97; SOT-363_SC-70-6; Digi-Key PN 1727-1772-1-ND

Connections:
Flash_Slideshow_Mode_LED: R2307.1, U2304.6; also elsewhere on the board
MLVDS_Stream_Mode_LED: R2302.1, U2302.6; also elsewhere on the board
unnamed: D2301.1 (K), U2301.4
unnamed: D2301.2 (A), R2304.2
unnamed: D2302.1 (K), U2302.4
unnamed: D2302.2 (A), R2305.2
unnamed: D2303.1 (K), U2303.4
unnamed: D2303.2 (A), R2306.2
unnamed: D2304.1 (K), U2304.4
unnamed: D2304.2 (A), R2310.2
unnamed: D2305.1 (K), U2305.4
unnamed: D2305.2 (A), R2311.2
unnamed: D2306.1 (K), U2306.4
unnamed: D2306.2 (A), R2312.2
unnamed: D2307.1 (K), U2307.4
unnamed: D2307.2 (A), R2315.2
unnamed: D2308.1 (K), U2308.4
unnamed: D2308.2 (A), R2316.2
Prog1_Mode_LED: R2308.1, U2305.6; also elsewhere on the board
Prog2_Mode_LED: R2314.1, U2308.6; also elsewhere on the board
Prog3_Mode_LED: R2303.1, U2303.6; also elsewhere on the board
Prog4_Mode_LED: R2309.1, U2306.6; also elsewhere on the board
USB_Stream_Mode_LED: R2301.1, U2301.6; also elsewhere on the board
Void_Mode_LED: R2313.1, U2307.6; also elsewhere on the board

Schematic: SPI_Flash_0.sch, LED Panel Controller

Parts:
C2401, C2402: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
D2401: Green; LED_0402; Digi-Key PN 1497-1219-1-ND
R2401: 1k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT1K00CT-ND
R2402, R2403, R2404, R2409: 10; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10R0CT-ND
R2405, R2406, R2407, R2408: 10k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10K0CT-ND
U2401: 74LVC1G97; SOT-363_SC-70-6; Digi-Key PN 1727-1772-1-ND
U2402: SST25VF080B; SOIC-8_5.275x5.275mm_P1.27mm; Digi-Key PN SST25VF080B-50-4I-S2AE-T

Connections:
FLASH_SPI_MISO: R2409.2; also elsewhere on the board
FLASH_SPI_MOSI: R2402.2; also elsewhere on the board
FLASH_SPI_SCK: R2403.2; also elsewhere on the board
unnamed: D2401.1 (K), U2401.4
unnamed: D2401.2 (A), R2401.2
unnamed: R2402.1, R2407.1, U2402.5 (SI)
unnamed: R2403.1, R2406.1, U2402.6 (SCK)
unnamed: R2404.1, R2405.2, U2402.1 (~CE)
unnamed: R2408.1, R2409.1, U2402.2 (SO)
~FLASH_SPI_CE0: R2404.2, U2401.1; also elsewhere on the board

Schematic: SPI_Flash_1.sch, LED Panel Controller

Parts:
C2501, C2502: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
D2501: Green; LED_0402; Digi-Key PN 1497-1219-1-ND
R2501: 1k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT1K00CT-ND
R2502, R2503, R2504, R2509: 10; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10R0CT-ND
R2505, R2506, R2507, R2508: 10k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10K0CT-ND
U2501: 74LVC1G97; SOT-363_SC-70-6; Digi-Key PN 1727-1772-1-ND
U2502: SST25VF080B; SOIC-8_5.275x5.275mm_P1.27mm; Digi-Key PN SST25VF080B-50-4I-S2AE-T

Connections:
FLASH_SPI_MISO: R2509.2; also elsewhere on the board
FLASH_SPI_MOSI: R2502.2; also elsewhere on the board
FLASH_SPI_SCK: R2503.2; also elsewhere on the board
unnamed: D2501.1 (K), U2501.4
unnamed: D2501.2 (A), R2501.2
unnamed: R2502.1, R2507.1, U2502.5 (SI)
unnamed: R2503.1, R2506.1, U2502.6 (SCK)
unnamed: R2504.1, R2505.2, U2502.1 (~CE)
unnamed: R2508.1, R2509.1, U2502.2 (SO)
~FLASH_SPI_CE1: R2504.2, U2501.1; also elsewhere on the board

Schematic: SPI_Flash_2.sch, LED Panel Controller

Parts:
C2601, C2602: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
D2601: Green; LED_0402; Digi-Key PN 1497-1219-1-ND
R2601: 1k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT1K00CT-ND
R2602, R2603, R2604, R2609: 10; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10R0CT-ND
R2605, R2606, R2607, R2608: 10k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10K0CT-ND
U2601: 74LVC1G97; SOT-363_SC-70-6; Digi-Key PN 1727-1772-1-ND
U2602: SST25VF080B; SOIC-8_5.275x5.275mm_P1.27mm; Digi-Key PN SST25VF080B-50-4I-S2AE-T

Connections:
FLASH_SPI_MISO: R2609.2; also elsewhere on the board
FLASH_SPI_MOSI: R2602.2; also elsewhere on the board
FLASH_SPI_SCK: R2603.2; also elsewhere on the board
unnamed: D2601.1 (K), U2601.4
unnamed: D2601.2 (A), R2601.2
unnamed: R2602.1, R2607.1, U2602.5 (SI)
unnamed: R2603.1, R2606.1, U2602.6 (SCK)
unnamed: R2604.1, R2605.2, U2602.1 (~CE)
unnamed: R2608.1, R2609.1, U2602.2 (SO)
~FLASH_SPI_CE2: R2604.2, U2601.1; also elsewhere on the board

Schematic: SPI_Flash_3.sch, LED Panel Controller

Parts:
C2701, C2702: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
D2701: Green; LED_0402; Digi-Key PN 1497-1219-1-ND
R2701: 1k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT1K00CT-ND
R2702, R2703, R2704, R2709: 10; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10R0CT-ND
R2705, R2706, R2707, R2708: 10k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10K0CT-ND
U2701: 74LVC1G97; SOT-363_SC-70-6; Digi-Key PN 1727-1772-1-ND
U2702: SST25VF080B; SOIC-8_5.275x5.275mm_P1.27mm; Digi-Key PN SST25VF080B-50-4I-S2AE-T

Connections:
FLASH_SPI_MISO: R2709.2; also elsewhere on the board
FLASH_SPI_MOSI: R2702.2; also elsewhere on the board
FLASH_SPI_SCK: R2703.2; also elsewhere on the board
unnamed: D2701.1 (K), U2701.4
unnamed: D2701.2 (A), R2701.2
unnamed: R2702.1, R2707.1, U2702.5 (SI)
unnamed: R2703.1, R2706.1, U2702.6 (SCK)
unnamed: R2704.1, R2705.2, U2702.1 (~CE)
unnamed: R2708.1, R2709.1, U2702.2 (SO)
~FLASH_SPI_CE3: R2704.2, U2701.1; also elsewhere on the board

Schematic: SPI_Flash_4.sch, LED Panel Controller

Parts:
C2801, C2802: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
D2801: Green; LED_0402; Digi-Key PN 1497-1219-1-ND
R2801: 1k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT1K00CT-ND
R2802, R2803, R2804, R2809: 10; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10R0CT-ND
R2805, R2806, R2807, R2808: 10k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10K0CT-ND
U2801: 74LVC1G97; SOT-363_SC-70-6; Digi-Key PN 1727-1772-1-ND
U2802: SST25VF080B; SOIC-8_5.275x5.275mm_P1.27mm; Digi-Key PN SST25VF080B-50-4I-S2AE-T

Connections:
FLASH_SPI_MISO: R2809.2; also elsewhere on the board
FLASH_SPI_MOSI: R2802.2; also elsewhere on the board
FLASH_SPI_SCK: R2803.2; also elsewhere on the board
unnamed: D2801.1 (K), U2801.4
unnamed: D2801.2 (A), R2801.2
unnamed: R2802.1, R2807.1, U2802.5 (SI)
unnamed: R2803.1, R2806.1, U2802.6 (SCK)
unnamed: R2804.1, R2805.2, U2802.1 (~CE)
unnamed: R2808.1, R2809.1, U2802.2 (SO)
~FLASH_SPI_CE4: R2804.2, U2801.1; also elsewhere on the board

Schematic: SPI_Flash_5.sch, LED Panel Controller

Parts:
C2901, C2902: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
D2901: Green; LED_0402; Digi-Key PN 1497-1219-1-ND
R2901: 1k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT1K00CT-ND
R2902, R2903, R2904, R2909: 10; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10R0CT-ND
R2905, R2906, R2907, R2908: 10k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10K0CT-ND
U2901: 74LVC1G97; SOT-363_SC-70-6; Digi-Key PN 1727-1772-1-ND
U2902: SST25VF080B; SOIC-8_5.275x5.275mm_P1.27mm; Digi-Key PN SST25VF080B-50-4I-S2AE-T

Connections:
FLASH_SPI_MISO: R2909.2; also elsewhere on the board
FLASH_SPI_MOSI: R2902.2; also elsewhere on the board
FLASH_SPI_SCK: R2903.2; also elsewhere on the board
unnamed: D2901.1 (K), U2901.4
unnamed: D2901.2 (A), R2901.2
unnamed: R2902.1, R2907.1, U2902.5 (SI)
unnamed: R2903.1, R2906.1, U2902.6 (SCK)
unnamed: R2904.1, R2905.2, U2902.1 (~CE)
unnamed: R2908.1, R2909.1, U2902.2 (SO)
~FLASH_SPI_CE5: R2904.2, U2901.1; also elsewhere on the board

Schematic: SPI_Flash_6.sch, LED Panel Controller

Parts:
C3001, C3002: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
D3001: Green; LED_0402; Digi-Key PN 1497-1219-1-ND
R3001: 1k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT1K00CT-ND
R3002, R3003, R3004, R3009: 10; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10R0CT-ND
R3005, R3006, R3007, R3008: 10k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10K0CT-ND
U3001: 74LVC1G97; SOT-363_SC-70-6; Digi-Key PN 1727-1772-1-ND
U3002: SST25VF080B; SOIC-8_5.275x5.275mm_P1.27mm; Digi-Key PN SST25VF080B-50-4I-S2AE-T

Connections:
FLASH_SPI_MISO: R3009.2; also elsewhere on the board
FLASH_SPI_MOSI: R3002.2; also elsewhere on the board
FLASH_SPI_SCK: R3003.2; also elsewhere on the board
unnamed: D3001.1 (K), U3001.4
unnamed: D3001.2 (A), R3001.2
unnamed: R3002.1, R3007.1, U3002.5 (SI)
unnamed: R3003.1, R3006.1, U3002.6 (SCK)
unnamed: R3004.1, R3005.2, U3002.1 (~CE)
unnamed: R3008.1, R3009.1, U3002.2 (SO)
~FLASH_SPI_CE6: R3004.2, U3001.1; also elsewhere on the board

Schematic: SPI_Flash_7.sch, LED Panel Controller

Parts:
C3101, C3102: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
D3101: Green; LED_0402; Digi-Key PN 1497-1219-1-ND
R3101: 1k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT1K00CT-ND
R3102, R3103, R3104, R3109: 10; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10R0CT-ND
R3105, R3106, R3107, R3108: 10k; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10K0CT-ND
U3101: 74LVC1G97; SOT-363_SC-70-6; Digi-Key PN 1727-1772-1-ND
U3102: SST25VF080B; SOIC-8_5.275x5.275mm_P1.27mm; Digi-Key PN SST25VF080B-50-4I-S2AE-T

Connections:
FLASH_SPI_MISO: R3109.2; also elsewhere on the board
FLASH_SPI_MOSI: R3102.2; also elsewhere on the board
FLASH_SPI_SCK: R3103.2; also elsewhere on the board
unnamed: D3101.1 (K), U3101.4
unnamed: D3101.2 (A), R3101.2
unnamed: R3102.1, R3107.1, U3102.5 (SI)
unnamed: R3103.1, R3106.1, U3102.6 (SCK)
unnamed: R3104.1, R3105.2, U3102.1 (~CE)
unnamed: R3108.1, R3109.1, U3102.2 (SO)
~FLASH_SPI_CE7: R3104.2, U3101.1; also elsewhere on the board

Schematic: Panel_Level_Shifters.sch, LED Panel Controller

Parts:
C3201, C3202, C3203: 0.1uF; C_0402; Voltage 50V; Digi-Key PN 490-10698-1-ND
R3201, R3202, R3203, R3204, R3205, R3206, R3207, R3208, R3209, R3210, R3211, R3212, R3213, R3214, R3249, R3250, R3251, R3252, R3253, R3254, R3255, R3256, R3257, R3258, R3259, R3260, R3261, R3262: 10; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10R0CT-ND
R3215, R3216, R3217, R3218, R3219, R3220, R3221, R3222, R3223, R3224, R3225, R3226, R3227, R3228, R3229, R3230, R3231, R3232, R3233, R3234, R3235, R3236, R3237, R3238, R3239, R3240, R3241, R3242, R3243, R3244, R3245, R3246, R3247, R3248: 10K; R_0402; Tolerance 1%; Digi-Key PN RMCF0402FT10K0CT-ND
U3201: 74LVC1G97; SOT-363_SC-70-6; Digi-Key PN 1727-1772-1-ND
U3202, U3203: 74HCT541; SSOP-20_4.4x6.5mm_Pitch0.65mm; Digi-Key PN 296-26499-1-ND

Connections:
+5V: C3202.1, C3203.1, R3248.1, U3202.20 (VCC), U3203.20 (VCC); also elsewhere on the board
B0_POS3P3: R3204.2; also elsewhere on the board
B0_POS5: R3252.2; also elsewhere on the board
B1_POS3P3: R3201.2; also elsewhere on the board
B1_POS5: R3249.2; also elsewhere on the board
G0_POS3P3: R3205.2; also elsewhere on the board
G0_POS5: R3253.2; also elsewhere on the board
G1_POS3P3: R3202.2; also elsewhere on the board
G1_POS5: R3250.2; also elsewhere on the board
unnamed: R3201.1, R3219.1, U3202.2 (A0)
unnamed: R3202.1, R3221.1, U3202.3 (A1)
unnamed: R3203.1, R3223.1, U3202.4 (A2)
unnamed: R3204.1, R3225.1, U3202.5 (A3)
unnamed: R3205.1, R3227.1, U3202.6 (A4)
unnamed: R3206.1, R3229.1, U3202.7 (A5)
unnamed: R3207.1, R3220.1, U3203.2 (A0)
unnamed: R3208.1, R3222.1, U3203.3 (A1)
unnamed: R3209.1, R3224.1, U3203.4 (A2)
unnamed: R3210.1, R3226.1, U3203.5 (A3)
unnamed: R3211.1, R3228.1, U3203.6 (A4)
unnamed: R3212.1, R3230.1, U3203.7 (A5)
unnamed: R3213.1, R3232.1, U3203.8 (A6)
unnamed: R3214.1, R3234.1, U3203.9 (A7)
unnamed: R3231.1, U3202.8 (A6)
unnamed: R3233.1, U3202.9 (A7)
unnamed: R3235.1, R3262.1, U3203.11 (Y7)
unnamed: R3236.1, R3261.1, U3203.12 (Y6)
unnamed: R3237.1, R3254.1, U3202.13 (Y5)
unnamed: R3238.1, R3260.1, U3203.13 (Y5)
unnamed: R3239.1, R3253.1, U3202.14 (Y4)
unnamed: R3240.1, R3259.1, U3203.14 (Y4)
unnamed: R3241.1, R3252.1, U3202.15 (Y3)
unnamed: R3242.1, R3258.1, U3203.15 (Y3)
unnamed: R3243.1, R3251.1, U3202.16 (Y2)
unnamed: R3244.1, R3257.1, U3203.16 (Y2)
unnamed: R3245.1, R3250.1, U3202.17 (Y1)
unnamed: R3246.1, R3256.1, U3203.17 (Y1)
unnamed: R3247.1, R3249.1, U3202.18 (Y0)
unnamed: R3248.2, R3255.1, U3203.18 (Y0)
Panel_CLK_POS3P3: R3209.2; also elsewhere on the board
Panel_CLK_POS5: R3257.2; also elsewhere on the board
Panel_Dim_PWM: R3216.1, U3201.1; also elsewhere on the board
Panel_LAT_POS3P3: R3208.2; also elsewhere on the board
Panel_LAT_POS5: R3256.2; also elsewhere on the board
R0_POS3P3: R3206.2; also elsewhere on the board
R0_POS5: R3254.2; also elsewhere on the board
R1_POS3P3: R3203.2; also elsewhere on the board
R1_POS5: R3251.2; also elsewhere on the board
Row_A_POS3P3: R3213.2; also elsewhere on the board
Row_A_POS5: R3261.2; also elsewhere on the board
Row_B_POS3P3: R3212.2; also elsewhere on the board
Row_B_POS5: R3260.2; also elsewhere on the board
Row_C_POS3P3: R3211.2; also elsewhere on the board
Row_C_POS5: R3259.2; also elsewhere on the board
Row_D_POS3P3: R3210.2; also elsewhere on the board
Row_D_POS5: R3258.2; also elsewhere on the board
Row_E_POS3P3: R3214.2; also elsewhere on the board
Row_E_POS5: R3262.2; also elsewhere on the board
~Panel_Level_Shift_Enable: R3217.2, R3218.2, U3202.1 (G1), U3202.19 (G2), U3203.1 (G1), U3203.19 (G2)
~Panel_OE_DIM_POS3P3: R3207.2, U3201.4
~Panel_OE_POS3P3: R3215.2, U3201.6; also elsewhere on the board
~Panel_OE_POS5: R3255.2; also elsewhere on the board

Schematic: Panel_Connectors.sch, LED Panel Controller

Parts:
C3301: 15pF; C_0402; Voltage 50V; Digi-Key PN 587-1949-1-ND
C3302: 100uF; CP_Tantalum_Case-X_EIA-7343-43_Reflow; Voltage 16V; Tolerance 10%; Digi-Key PN 718-1102-1-ND
D3301, D3302, D3303: SP0505BAJT; SOT-363_SC-70-6; Digi-Key PN F3160CT-ND
J3301: Panel Data; PinSocket_2x08_P2.54mm_Vertical; Digi-Key PN S9196-ND
J3302: Keystone_8191; Digi-Key PN 36-8191-ND

Connections:
+5V: C3302.1, J3302.1; also elsewhere on the board
B0_POS5: D3301.5 (K), J3301.3; also elsewhere on the board
B1_POS5: D3302.1 (K), J3301.7; also elsewhere on the board
G0_POS5: D3301.6 (K), J3301.2; also elsewhere on the board
G1_POS5: D3301.3 (K), J3301.6; also elsewhere on the board
Panel_CLK_POS5: D3303.6 (K), J3301.13; also elsewhere on the board
Panel_LAT_POS5: D3303.5 (K), J3301.14; also elsewhere on the board
R0_POS5: D3301.1 (K), J3301.1; also elsewhere on the board
R1_POS5: D3301.4 (K), J3301.5; also elsewhere on the board
Row_A_POS5: D3302.5 (K), J3301.9; also elsewhere on the board
Row_B_POS5: D3302.4 (K), J3301.10; also elsewhere on the board
Row_C_POS5: D3302.3 (K), J3301.11; also elsewhere on the board
Row_D_POS5: D3303.1 (K), J3301.12; also elsewhere on the board
Row_E_POS5: D3302.6 (K), J3301.8; also elsewhere on the board
~Panel_OE_POS5: C3301.1, D3303.4 (K), J3301.15; also elsewhere on the board

Notes on the sheet:
Place on Bottom
Add cut in PCB to allow for power harness to pass through to panel

Schematic: Mechanical.sch, LED Panel Controller

Parts:
H3401, H3402, H3403, H3404: MountingHole; MountingHole_3mm
MK3401, MK3402, MK3405, MK3406: Standoff; Digi-Key PN 1772-1220-ND
MK3403, MK3404, MK3407, MK3408: Screw; Digi-Key PN 36-9900-ND

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